# IAR project lib_lpc_board_nxp_lpcxpresso_1343.ewp, settings and files
configuration nxp_lpcxpresso_1343 (ARM)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\lpc_chip\chip_common; ..\..\..\lpc_chip\chip_13xx; ..\..\..\lpc_chip\chip_13xx\config_1343; ..\..\..\lpc_board\board_common; $PROJ_DIR$; ..\..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_nxp_lpcxpresso_1343
    ./: board.c board_sysinit.c
