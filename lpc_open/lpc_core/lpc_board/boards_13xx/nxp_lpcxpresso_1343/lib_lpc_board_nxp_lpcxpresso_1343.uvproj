# Keil uVision project lib_lpc_board_nxp_lpcxpresso_1343.uvproj, settings and files
target nxp_lpcxpresso_1343 (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: board_nxp_lpcxpresso_1343 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_13xx;..\..\..\lpc_chip\chip_common;..\..\..\lpc_chip\chip_13xx\config_1343;..\..\board_common;..\nxp_lpcxpresso_1343
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group board_nxp_lpcxpresso_1343
    ./: board.c board_sysinit.c
