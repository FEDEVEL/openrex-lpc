# Keil uVision project lib_lpc_chip_1343.uvproj, settings and files
target chip_1343_lib (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: chip_1343_lib (library)
  c flags: Optim=4 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\software\lpc_core\lpc_chip\chip_13xx;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\CMSIS;.\config_1343
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group csp
    ./: adc_13xx.c chip_13xx.c clock_13xx.c gpio_13xx_1.c gpio_13xx_2.c i2c_13xx.c iocon_13xx.c pmu_13xx.c ssp_13xx.c sysctl_13xx.c sysinit_13xx.c timer_13xx.c uart_13xx.c wwdt_13xx.c flash_13xx.c stopwatch_13xx.c
    ../chip_common/: ring_buffer.c
