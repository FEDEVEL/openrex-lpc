# IAR project lib_lpc_chip_1343.ewp, settings and files
configuration chip_13xx_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; config_1343; ../chip_common; ../../../CMSIS/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group csp
    ./: adc_13xx.c chip_13xx.c clock_13xx.c gpio_13xx_2.c i2c_13xx.c iocon_13xx.c pmu_13xx.c ssp_13xx.c stopwatch_13xx.c sysctl_13xx.c sysinit_13xx.c timer_13xx.c uart_13xx.c wwdt_13xx.c
    ../chip_common/: ring_buffer.c
